# Keil uVision project My_STM32F103_Project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My_STM32F103_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Library\inc;..\Library\src;..\User;..\User\CAN;..\User\Common;..\User\IIC;..\User\LED;..\User\Motor;..\User\MPU6050;..\User\MPU6050\DMP;..\User\PWM;..\User\Ultrasonic;..\User\Kalman
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Library
    ../Library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dac.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c
  group User
    ../User/: main.c
    ../User/Common/: common.c
    ../User/IIC/: analog_I2C.c hardware_I2C.c
